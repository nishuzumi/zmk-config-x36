## config/boards/shields/x36/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_x36
    def_bool $(shields_list_contains,x36)
```
